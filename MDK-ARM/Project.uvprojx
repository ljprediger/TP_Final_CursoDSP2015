# Keil uVision project Project.uvprojx, settings and files
target STM32F401-DISCO (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F401VCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F401-DISCO
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xC,USE_STM32F401_DISCO,ARM_MATH_CM4,__FPU_PRESENT=1,UNALIGNED_SUPPORT_DISABLE
  c misc: --C99
  c include: ..\Inc;..\STM32Cube_FW_F4_V1.5.0\Drivers\CMSIS\Include;..\STM32Cube_FW_F4_V1.5.0\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\STM32Cube_FW_F4_V1.5.0\Drivers\STM32F4xx_HAL_Driver\Inc;..\STM32Cube_FW_F4_V1.5.0\Drivers\BSP\STM32F401-Discovery;..\STM32Cube_FW_F4_V1.5.0\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\STM32Cube_FW_F4_V1.5.0\Middlewares\ST\STM32_USB_HOST_Library\Class\MSC\Inc;..\STM32Cube_FW_F4_V1.5.0\Middlewares\ST\STM32_USB_HOST_Library\Core\Inc;..\STM32Cube_FW_F4_V1.5.0\Middlewares\ST\STM32_Audio\Addons\PDM;..\STM32Cube_FW_F4_V1.5.0\Middlewares\Third_Party\FatFs\src;..\STM32Cube_FW_F4_V1.5.0\Middlewares\Third_Party\FatFs\src\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Application/User
    ../src/: main.c stm32f4xx_it.c usbh_conf.c waveplayer.c
    ../Src/: application.c waverecorder.c utils.c fputc_debug.c audioFilter.c filters.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../STM32Cube_FW_F4_V1.5.0/Drivers/BSP/Components/cs43l22/: cs43l22.c
    ../STM32Cube_FW_F4_V1.5.0/Drivers/BSP/Components/lsm303dlhc/: lsm303dlhc.c
  group Drivers/BSP/STM32F401-Discovery
    ../STM32Cube_FW_F4_V1.5.0/Drivers/BSP/STM32F401-Discovery/: stm32f401_discovery.c stm32f401_discovery_accelerometer.c stm32f401_discovery_audio.c
  group Drivers/CMSIS
    ../src/: system_stm32f4xx.c
    ../STM32Cube_FW_F4_V1.5.0/Drivers/CMSIS/DSP_Lib/Source/FilteringFunctions/: arm_fir_fast_q15.c arm_fir_init_q15.c arm_fir_q15.c
    ../STM32Cube_FW_F4_V1.5.0/Drivers/CMSIS/DSP_Lib/Source/StatisticsFunctions/: arm_rms_q15.c
    ../STM32Cube_FW_F4_V1.5.0/Drivers/CMSIS/DSP_Lib/Source/FastMathFunctions/: arm_sqrt_q15.c
  group Drivers/STM32F4xx_HAL_Drivers
    ../STM32Cube_FW_F4_V1.5.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_ll_usb.c stm32f4xx_hal_dma_ex.c
  group Middlewares/FatFs/Core
    ../STM32Cube_FW_F4_V1.5.0/Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../STM32Cube_FW_F4_V1.5.0/Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c
  group Middlewares/FatFs/Options
    ../STM32Cube_FW_F4_V1.5.0/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/PDM
    ../STM32Cube_FW_F4_V1.5.0/Middlewares/ST/STM32_Audio/Addons/PDM/: libPDMFilter_CM4_IAR.a
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../STM32Cube_FW_F4_V1.5.0/Middlewares/ST/STM32_USB_HOST_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/STM32_USBH_Library/Core
    ../STM32Cube_FW_F4_V1.5.0/Middlewares/ST/STM32_USB_HOST_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
